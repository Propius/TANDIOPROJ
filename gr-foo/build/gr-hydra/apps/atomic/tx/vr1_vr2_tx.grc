<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude1</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude2</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>cpu_percent</value></param>
<param><key>block_id</key><value>zcpu</value></param>
<param><key>function_name</key><value>cpu_percent</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq1</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>2.484e9-500e3</value></param>
<param><key>option</key><value>"txfreq1"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq2</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>2.484e9+500e3</value></param>
<param><key>option</key><value>"txfreq2"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>lte_rate</value></param>
<param><key>block_id</key><value>zzlte_rate</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>lte_tx_goodput</value></param>
<param><key>block_id</key><value>zlterate</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>nbiot_rate</value></param>
<param><key>block_id</key><value>zznbiot_rate</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>poll_rate</key><value>1</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>nbiot_tx_goodput</value></param>
<param><key>block_id</key><value>znbiotrate</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>poll_rate</key><value>10</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(sorted(tuple(set([x for x in range(-26,27)]) - set(pilot_carriers[0]) - set([0,]))),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pattern1</value></param>
<param><key>value</key><value>[0., 1.41421356, 0., -1.41421356]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pattern2</value></param>
<param><key>value</key><value>[1, -1, 1, -1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-27, -14, -7, 7, 14, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((-1,1, 1, -1, -1, -1),)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samprate</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>option</key><value>"samprate"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samprate1</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>option</key><value>"samprate1"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samprate2</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>200e3</value></param>
<param><key>option</key><value>"samprate2"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + pattern1 * ((fft_len-12)/len(pattern1))  +[0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0.,] + pattern2 * ((fft_len-12)/len(pattern2))  +[0., 0., 0., 0., 0., 0.,] </value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>txfreq</value></param>
<param><key>config_file</key><value>./default</value></param>
<param><key>value</key><value>2.484e9</value></param>
<param><key>option</key><value>"txfreq"</value></param>
<param><key>section</key><value>"usrp_hydra"</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_fftlen</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_pattern1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[0., 1.41421356, 0., -1.41421356]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_pattern2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1, -1, 1, -1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vr1_pilot_carriers</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>((-27, -14, -7, 7, 14, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zcpu</value></param>
<param><key>value</key><value>psutil</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>acpu</value></param>
<param><key>import</key><value>import psutil</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>amplitude1</value></param>
<param><key>label</key><value>amplitude1</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>amplitude2</value></param>
<param><key>label</key><value>amplitude2</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0_0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>amplitude1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>amplitude2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"length"</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"length"</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>Tx'd Packet</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>6544</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>192.168.5.242</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>22</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_1</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>"length"</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>pilot_carriers</key><value>pilot_carriers</value></param>
<param><key>pilot_symbols</key><value>pilot_symbols</value></param>
<param><key>rolloff</key><value>0</value></param>
<param><key>sync_word1</key><value>sync_word1</value></param>
<param><key>sync_word2</key><value>sync_word2</value></param>
</block>
<block>
<key>digital_ofdm_tx</key>
<param><key>id</key><value>digital_ofdm_tx_0_0</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>header_mod</key><value>"BPSK"</value></param>
<param><key>packet_len_key</key><value>length</value></param>
<param><key>payload_mod</key><value>"BPSK"</value></param>
<param><key>rolloff</key><value>0</value></param>
</block>
<block>
<key>hydra_hydra_sink</key>
<param><key>id</key><value>hydra_hydra_sink_0</value></param>
<param><key>bandwidth</key><value>samprate</value></param>
<param><key>central_frequency</key><value>txfreq</value></param>
<param><key>fft_m_size</key><value>1024</value></param>
<param><key>center_freq1</key><value>freq1</value></param>
<param><key>center_freq10</key><value></value></param>
<param><key>center_freq11</key><value></value></param>
<param><key>center_freq12</key><value></value></param>
<param><key>center_freq13</key><value></value></param>
<param><key>center_freq14</key><value></value></param>
<param><key>center_freq15</key><value></value></param>
<param><key>center_freq16</key><value></value></param>
<param><key>center_freq17</key><value></value></param>
<param><key>center_freq18</key><value></value></param>
<param><key>center_freq19</key><value></value></param>
<param><key>center_freq2</key><value>freq2</value></param>
<param><key>center_freq20</key><value></value></param>
<param><key>center_freq21</key><value></value></param>
<param><key>center_freq22</key><value></value></param>
<param><key>center_freq23</key><value></value></param>
<param><key>center_freq24</key><value></value></param>
<param><key>center_freq25</key><value></value></param>
<param><key>center_freq26</key><value></value></param>
<param><key>center_freq27</key><value></value></param>
<param><key>center_freq28</key><value></value></param>
<param><key>center_freq29</key><value></value></param>
<param><key>center_freq3</key><value></value></param>
<param><key>center_freq30</key><value></value></param>
<param><key>center_freq4</key><value></value></param>
<param><key>center_freq5</key><value></value></param>
<param><key>center_freq6</key><value></value></param>
<param><key>center_freq7</key><value></value></param>
<param><key>center_freq8</key><value></value></param>
<param><key>center_freq9</key><value></value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samprate1</key><value>samprate1</value></param>
<param><key>samprate10</key><value></value></param>
<param><key>samprate11</key><value></value></param>
<param><key>samprate12</key><value></value></param>
<param><key>samprate13</key><value></value></param>
<param><key>samprate14</key><value></value></param>
<param><key>samprate15</key><value></value></param>
<param><key>samprate16</key><value></value></param>
<param><key>samprate17</key><value></value></param>
<param><key>samprate18</key><value></value></param>
<param><key>samprate19</key><value></value></param>
<param><key>samprate2</key><value>samprate2</value></param>
<param><key>samprate20</key><value></value></param>
<param><key>samprate21</key><value></value></param>
<param><key>samprate22</key><value></value></param>
<param><key>samprate23</key><value></value></param>
<param><key>samprate24</key><value></value></param>
<param><key>samprate25</key><value></value></param>
<param><key>samprate26</key><value></value></param>
<param><key>samprate27</key><value></value></param>
<param><key>samprate28</key><value></value></param>
<param><key>samprate29</key><value></value></param>
<param><key>samprate3</key><value></value></param>
<param><key>samprate30</key><value></value></param>
<param><key>samprate4</key><value></value></param>
<param><key>samprate5</key><value></value></param>
<param><key>samprate6</key><value></value></param>
<param><key>samprate7</key><value></value></param>
<param><key>samprate8</key><value></value></param>
<param><key>samprate9</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>txfreq</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>0.9</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samprate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>vr1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>vr2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>vr1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>vr2</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>1235</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>zlterate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>2000</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>znbiotrate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>mintime</key><value>2000</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>zzlte_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>zznbiot_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>500.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>hydra_hydra_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>zzlte_rate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>hydra_hydra_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>zznbiot_rate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_ofdm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>zlterate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_tag_debug_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_ofdm_tx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>znbiotrate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_1</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_tx_0_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hydra_hydra_sink_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>hydra_hydra_sink_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
